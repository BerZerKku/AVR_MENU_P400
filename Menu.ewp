# IAR project Menu.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 64
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.newCCIncludePaths: INC
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\
  ICCAVR.IccLang: 0
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    doc/: readme_P400.txt
  group Common sources/inc
    inc/: board.h DataCenter.h DataCenter1.h debug.h delay.h driverLCD.h fifo.h Flash.h Menu.h MyDef.h peripheral.h UartBsp.h UartLs.h
  group Common sources/src
    src/: DataCenter.c DataCenter1.c driverLCD.c drvKeyboard.cpp Menu.c peripheral.cpp studyATmega162.c UartBsp.cpp UartLs.cpp
